# Keil uVision project Blynk.uvprojx, settings and files
target Blynk (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blynk
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c UART.c Blynk.c ST7735.c esp8266.c PortF.c buttonDriver.c Clock.c speaker.c timers.c buttonDriver.h Clock.h esp8266.h PLL.h PortF.h speaker.h ST7735.h Timer2.h Timer3.h timers.h UART.h
software components: CMSIS:CORE 5.0.2
